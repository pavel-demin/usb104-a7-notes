options:
  parameters:
    generate_options: qt_gui
    id: fm_usb
    output_language: python
  states: {}

blocks:
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    label: Frequency (MHz)
    start: '80'
    step: '0.1'
    stop: '120'
    value: '100.0'
  states: {}
- name: rx_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: rx_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      from pyhubio import PyhubIO, PyhubJTAG
      import numpy as np
      import time


      class source(gr.sync_block):
          rate_map = {
              24000: 2560,
              48000: 1280,
              96000: 640,
              192000: 320,
              384000: 160,
              768000: 80,
              1536000: 40,
          }
          adc_cfg = [
              0x00003C,
              0x000803,
              0x000800,
              0x000502,
              0x001421,
              0x000501,
              0x001431,
          ]

          def __init__(self, rate=48000, frequency=1000000):
              gr.sync_block.__init__(self, name="USB104 A7 Source", in_sig=None, out_sig=[np.complex64])
              self.rate = rate
              self.frequency = frequency
              self.config = np.zeros(4, np.uint32)
              self.status = np.zeros(1, np.uint32)
              self.io = None

          def start_io(self):
              if self.io:
                  return
              jtag = PyhubJTAG()
              jtag.start()
              jtag.flush()
              jtag.setup()
              jtag.idle()
              jtag.program("sdr_receiver.bit")
              time.sleep(0.1)
              self.io = PyhubIO()
              self.io.start()
              self.io.flush()
              self.io.write(np.uint32(self.adc_cfg), 2)
              self.io.write(np.uint32([1]), 0, 0)

          def work(self, input_items, output_items):
              self.start_io()
              out = output_items[0]
              if self.rate in self.rate_map:
                  self.config[1] = self.rate_map[self.rate]
              self.config[2] = np.floor(self.frequency / 122.88e6 * (1 << 30) + 0.5)
              self.config[3] = self.config[2] == 0
              self.io.write(self.config, 0, 1)
              self.io.read(self.status, 1, 0)
              cntr = self.status[0]
              if cntr >= 32768:
                  print("FIFO buffer overflow")
                  self.io.write(np.uint32([0]), 0, 0)
                  self.io.write(np.uint32([1]), 0, 0)
                  cntr = 0
              while cntr < out.size * 2:
                  time.sleep(0.001)
                  self.io.read(self.status, 1, 0)
                  cntr = self.status[0]
              self.io.read(out, 2, 0)
              return out.size
    frequency: rx_freq*1000000
    rate: rx_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '90000'
    decim: '1'
    gain: '1'
    samp_rate: rx_rate
    type: fir_filter_ccf
    width: '10000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rx_rate
    fc: rx_freq*1000000
    fftsize: '1024'
    name: ''
    showrf: 'True'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, '0', low_pass_filter_0, '0']
- [epy_block_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
